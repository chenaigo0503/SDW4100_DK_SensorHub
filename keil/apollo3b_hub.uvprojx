# Keil uVision project apollo3b_hub.uvprojx, settings and files
target apollo3b_hub (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.3
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: apollo3b_hub +hex
  AfterMake: fromelf --bin --output bin\apollo3b_hub.bin bin\apollo3b_hub.axf
  AfterMake: fromelf -cedrst --output bin\apollo3b_hub.txt bin\apollo3b_hub.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil
  c include: ..\src;..\utils;..\CMSIS\AmbiqMicro\Include;..\CMSIS\ARM\Include;..\mcu\apollo3;..\..\apollo3b_hub;..\bsp;..\devices;..\sensorhub;..\third_party\exactle\wsf\sources\util;..\bootloader;..\third_party\custom\crc8;..\devices\apollo_pah8011;..\devices\apollo_pah8011\PAH_MAIN;..\devices\apollo_pah8011\PAH8011;..\devices\apollo_pah8011\PAH8011\pah_comm_others;..\devices\apollo_pah8011\PAH8011\verify;..\devices\apollo_pah8011\PxiAlg\HR\v5551
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\apollo3b_hub.sct
  link misc: ../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group bsp
    ../bsp/: am_bsp.c am_bsp_pins.c
  group bootloader
    ../bootloader/: am_bootloader.c am_multi_boot.c
  group src
    ../src/: apollo3_init.c apollo3_uart.c main.c apollo3_amotas.c apollo3_ios.c apollo3_rtc.c
  group sensor_hub
    ../sensorhub/: apollo_delay2run.c apollo_message.c
  group devices
    ../devices/: apollo_lsm6dso.c apollo_ak09918.c apollo_bmp280.c
  group apollo_pah8011
    ../devices/apollo_pah8011/PAH8011/pah_comm_others/: pah_comm_i2c_length_limit.c
    ../devices/apollo_pah8011/PAH8011/: pah_driver_8011.c pah_driver_8011_reg_array.c pah_8011_internal.c
    ../devices/apollo_pah8011/PAH_MAIN/: pah_factory_test.c pah_hrd_function.c
    ../devices/apollo_pah8011/PAH8011/verify/: pah_verify_8011.c
    ../devices/apollo_pah8011/PxiAlg/HR/v5551/: pah8series_motion5551_1_m4f_keil.lib
  group third_party
    ../third_party/custom/crc8/: crc8.c
  group utils
    ../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_string.c am_util_time.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../mcu/apollo3/hal/keil/bin/: libam_hal.lib
